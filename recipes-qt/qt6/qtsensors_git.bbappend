PACKAGECONFIG += "examples"