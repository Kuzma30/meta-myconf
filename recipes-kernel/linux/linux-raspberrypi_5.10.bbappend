FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
	    file://0001-Patch-LT070ME05000.patch \
	    "
